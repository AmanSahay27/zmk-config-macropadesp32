## boards/shields/esp32/Kconfig.defconfig
```kconfig
if SHIELD_ESP32

config ZMK_KEYBOARD_NAME
    default "esp32c3"

endif # SHIELD_ESP32
```
